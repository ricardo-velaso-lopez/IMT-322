# Repository ricardo-velaso-lopez/IMT-322

## KiCad design 3.Practicas de kicad/1er diagrama.kicad_pcb

Parts:
D1: LED; LED_0805_2012Metric
D2: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
K1: Y14x-1C-xxDS; Relay_SPDT_HsinDa_Y14
Q1: BC547; TO-92_Inline
R1: 1K; R_0805_2012Metric
R2, R3: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: PC817; DIP-4_W7.62mm

Connections:
5v: D1.2 (A), D2.1 (K), K1.4, U1.4
COM: K1.5, K1.6
GNDREF: Q1.3 (E), U1.2
INPUT: R2.2
NC: K1.2
NO: K1.1
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), K1.3, Q1.1 (C), R3.2
unnamed: Q1.2 (B), R1.1
unnamed: R1.2, U1.3
unnamed: R2.1, U1.1

Board: 2 copper layers, 8 parts (0 on the bottom side), 8 nets, no tracks yet.

## Commit log

2024-02-16 Create Ejercicios
2024-02-17 readme nombre
2024-04-13 Create 1.practica de kicad
2024-04-27 Actualizar
2024-04-27 Add files via upload
    Definitivo
2024-05-10 Create Estructura Base del proyecto
2024-05-29 Create En lace para descargar el video
2024-11-26 Updated LED configuration in Practica11.ino
2024-11-26 3er intento
